DESCRIPTION = "ROS Control for the EV3 Sensors and base class to interact with the Lego drivers"
SECTION = "devel"

DEPENDS = "catkin roscpp message-generation message-runtime"

ROS_SPN = "h4r_ev3_msgs" 

require h4r-ev3_0.1.inc