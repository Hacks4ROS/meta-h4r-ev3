DESCRIPTION = "A interface for setting up ev3 motor joints"
SECTION = "devel"

DEPENDS = "catkin roscpp hardware-interface"

ROS_SPN = "h4r_ev3_joint_setup" 

require h4r-ev3_0.1.inc