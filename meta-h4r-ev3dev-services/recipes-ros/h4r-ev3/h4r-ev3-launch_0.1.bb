DESCRIPTION = "Example launchfiles for ROS node h4r_ev3_manager"
SECTION = "examples"

DEPENDS = "catkin"

ROS_SPN = "h4r_ev3_launch" 

require h4r-ev3_0.1.inc